Commit message: Update plate.urdf

File: data/objects/plate.urdf (robot description, URDF)
Before this commit: robot plate, 1 links, 0 joints
Links:
- link plate: geometry collision mesh filename=plate.stl; visual mesh filename=plate.stl
