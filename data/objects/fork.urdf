Commit message: fixed collision models for fork and kinova tool

File: data/objects/fork.urdf (robot description, URDF)
Before this commit: robot fork, 1 links, 0 joints
Links:
- link fork: geometry collision mesh filename=fork_collision.stl scale=1.0 1.00 1.00; visual mesh filename=fork.stl
