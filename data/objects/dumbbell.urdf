Commit message: Add dumbbell urdf

File: data/objects/dumbbell.urdf (robot description, URDF)
Before this commit: robot dumbbell, 1 links, 0 joints
Links:
- link base_link: geometry collision box size=0.1206 0.1206 0.0570; collision box size=0.1206 0.1206 0.0570
