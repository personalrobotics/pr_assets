Commit message: Make ceiling dimensions way more reasonable.

File: data/furniture/sniyaz_ceiling.urdf (robot description, URDF)
Before this commit: robot sniyaz_ceiling, 1 links, 0 joints
Links:
- link base_link: geometry collision box size=3.0 3.0 0.05295; visual box size=3.0 3.0 0.05295
